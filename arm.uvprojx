# Keil uVision project arm.uvprojx, settings and files
target arm (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: hal (library)
  AfterMake: .keil\copy.bat bsp_arterytek_at32f415.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iar.h cmsis_iccarm.h cmsis_version.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h mpu_armv7.h mpu_armv8.h package-info.h pmu_armv8.h
